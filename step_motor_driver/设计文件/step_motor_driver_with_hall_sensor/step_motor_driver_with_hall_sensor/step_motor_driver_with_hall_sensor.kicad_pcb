# Repository Fengling-Tech-Co-Ltd/JLC_Projects

File README.md:

# JLC_PROJECTS

硬件（立创EDA / KiCad）与配套固件的工程合集。每个子目录是一个独立项目，目录内自带 README 说明硬件要点、关键计算、固件用法与已知问题。

| 目录 | 项目 | 内容 |
|---|---|---|
| [`step_motor_driver/`](step_motor_driver/) | 双轴步进电机驱动板 | PY32F030K28T6 + DRV8825PWPR × 2，24 V 输入，含立创EDA 工程与已跑通的固件测试工程 |
| [`integrating_box_light_source/`](integrating_box_light_source/) | 积分盒四色光源板 | R/G/B/IR 四路恒流 LED，MCP4728 调光 + BPW34S/ADS1110 光强反馈，含 KiCad、立创EDA 与固件 |
| [`film_light_meter/`](film_light_meter/) | 胶片相机测光板 | PY32L020 + 双墨水屏 + OPT3001 光强 + QMA6100P 姿态，验证板；含方案文档与器件手册 |
| [`modular_slot_controller/`](modular_slot_controller/) | 模块插槽控制板 | 4 大板 × 4 小板 = 16 槽位；大板板号链与槽位编码，小板测温/液位/负载与金手指 I2C，含固件测试工程 |

## 阅读建议

每个子目录的 `README.md` 是入口：

- 硬件怎么接、怎么算 → 各项目 README 的"关键计算"一节
- 固件怎么编、怎么烧、怎么调 → 各项目的 `测试工程/` 与其 README
- 打板依据 → `设计文件/` 下的 `.epro`（立创EDA）或 `.kicad_pro`（KiCad）

## 说明

- 仓库只收录源工程、文档与固件源码；编译产物（`Output/`、`Objects/`、`Listings/`）、本机调试配置（`*.uvguix.*`）、
  本地历史（`.history/`、`*backups/`）与外层压缩包均不纳入
- 器件手册按用途归档在各项目目录内，文件名保留供应商原名，便于与采购规格书对照

## KiCad design step_motor_driver/设计文件/step_motor_driver_with_hall_sensor/step_motor_driver_with_hall_sensor/step_motor_driver_with_hall_sensor.kicad_pcb

File step_motor_driver/README.md:

# 步进电机驱动功能板（双轴）

PY32F030K28T6 主控 + 两片 DRV8825PWPR 的双轴步进电机驱动板，24 V 单电源输入，相电流 1.0~3.5 A 可调。含立创EDA 工程与一套已跑通的固件测试工程。

## 1. 硬件概览

| 项 | 值 |
|---|---|
| 主控 | PY32F030K28T6，Cortex-M0+，LQFP32，48 MHz，64 KB Flash / 8 KB SRAM |
| 驱动 | DRV8825PWPR × 2，ETSSOP-28 带散热焊盘 |
| 电机接口 | JST PH 2.0mm 4 芯卧插 × 2，额定 2 A |
| 输入 | 24 V DC，2 A 以上；PTC 自恢复保险 + 双向 TVS + 肖特基防反接 |
| 3.3 V | LM317MDT 线性稳压，带预负载 |
| 限流设定 | MCU 20 kHz PWM + RC 滤波，两轴独立 |
| 细分 | 全步（200 步/转），MODE0/1/2 硬件下拉固定 |
| 调试口 | 2×4 2.0mm 排针，含 SWD 与 USART1 |

## 2. 目录结构

```
设计文件/
  ProPrj_步进电机驱动功能板_2026-11-11.epro   立创EDA 专业版工程（当前依据）
  JLC_步进电机驱动功能板/README.md             硬件详细说明：引脚表、关键计算、器件清单
  step_motor_driver_with_hall_sensor/          带霍尔传感器的早期 KiCad 版本（非当前依据）
测试工程/
  PY32_Motor_Drive_Project/                    固件（PY32F030，Keil 工程）
    交接文档.md                                 硬件引脚、时钟、上电顺序、控制台命令
    User/ EWARM/ MDK-ARM/ 等
```

**硬件细节看 `设计文件/JLC_步进电机驱动功能板/README.md`**：里面有大板与小板的完整引脚对照、MCU↔DRV8825 网表、电机接口线序、定时器分工，以及更完整的计算过程。

## 3. 关键计算

| 项 | 值 | 依据 |
|---|---|---|
| 相电流设定 | `I_CHOP = VREF / (5 × Rcs)`，Rcs = 200 mΩ | 所以 VREF 每 1 V 对应 1 A |
| 电流范围 | 1.0 ~ 3.5 A，推荐工作点 1.5 A | 板级设计区间 |
| VREF PWM | TIM3，48 MHz，PSC=0，ARR=2399 → 20 kHz | `VREF = 3.3 × CCR / 2400` |
| CCR 换算 | `CCR = mA × 2400 / 3300` | 1.2 A → 873；1.5 A → 1091 |
| VREF RC | 10 kΩ / 1 µF，截止 15.9 Hz，建立约 30 ms | 设完电流必须等，否则电机猛冲 |
| STEP 频率 | `f = 48 MHz / ((PSC+1)(ARR+1))`，50% 占空比 | 上限 250 kHz（高低各 ≥1.9 µs） |
| 转速 | 全步 200 步/转，`RPM = 0.3 × f_STEP` | 1 kHz→300 rpm，10 kHz→3000 rpm |
| 3V3 | 3.28 V | `1.25 × (1 + 390/240)` |
| 母线储能 | 151 µF | 入口 57 µF + 每片驱动本地 47 µF |

定时器分工：TIM3 出两路 VREF（同频 20 kHz、占空比独立）；TIM16 出 STEP_1，TIM1 出 STEP_2。**STEP 与 VREF 不能共用定时器**，同一外设的通道共用 ARR。

## 4. 固件（测试工程）

`测试工程/PY32_Motor_Drive_Project`，详细说明见其 `交接文档.md`。当前状态：**两轴电机实测能转**。

- 时钟：HSI 24 M × PLL2 = 48 MHz；不能用 HSE（PF0/PF1 已作 USART，且无外部晶振）
- 上电顺序（不能调换）：nENBL 拉高禁用 → 写 VREF → 等 30 ms → 放开 nRESET → 等 10 µs → nENBL 拉低使能 → 才允许发 STEP
- 默认相电流 **1.2 A**（1.5 A 时结温约 121°C，散热余量不足）
- 控制台：USART1 115200 文本命令
- 两个自检宏：`PF1_TOGGLE_TEST`（PF1 当 GPIO 翻转，查走线）、`MOTOR_DEMO_ENABLE`（开机自动跑动作）

## 5. 已知设计与验证状态

**已完成**

- 5 张原理图（PWR / MCU / 驱动一 / 驱动二 / DEBUG）完成，引脚复用与外围参数已按手册核对
- 立创EDA 工程可打开，BOM 中的关键器件已选定
- 固件：双轴 STEP/DIR/ENBL、20 kHz VREF 调流、按步数运动与连续转、控制台均已实现，两轴实机转动验证通过

**未完成 / 已知取舍**

| 项 | 说明 |
|---|---|
| nFAULT | 只做上拉，未接回 MCU，**故障不可上报** |
| DECAY | 悬空 = 混合衰减，未做软件可选 |
| 满载散热 | 1.5 A 时结温约 121°C，固件默认降到 1.2 A；需实测底板温度 |
| PCB | 已绘制完成，**尚未打样** |
| 交付件 | BOM、Gerber 待补齐 |
| Rcs 封装功耗 | 200 mΩ 采样电阻需 2512 / 1 W / 1%，功耗待复核 |
| 霍尔版本 | `step_motor_driver_with_hall_sensor` 是早期 KiCad 变体，非当前打板依据 |

## 6. 打开方式

- **硬件**：立创EDA 专业版打开 `设计文件/ProPrj_步进电机驱动功能板_2026-11-11.epro`
  - 工程内网络名统一用下划线（`STEP_1` / `STEP_2`），立创EDA 会把带空格的同名网络当成两个网络
- **固件**：Keil MDK 打开 `测试工程/PY32_Motor_Drive_Project/MDK-ARM/Project.uvprojx`
- **参考手册**：DRV8825 及兼容型号（HR8825 / TMI8420 / A4988 / HR4988）的资料在本地数据手册库的电机驱动分类下

## 7. 提交到 Git 的建议

优先保留：`设计文件/*.epro`、`设计文件/JLC_步进电机驱动功能板/README.md`、`测试工程/PY32_Motor_Drive_Project`（源码 + 交接文档）。

建议**不要**提交：

| 排除项 | 原因 |
|---|---|
| `测试工程/.../MDK-ARM/Output/`、`Objects/`、`Listings/` | 编译产物，单是 Output 就 40 MB 量级 |
| `*.uvguix.*`、`JLinkLog.txt` | 本机调试配置与日志 |
| `step_motor_driver_with_hall_sensor/` 里的 `.history/`、`*backups/` | KiCad 本地历史 |

.gitignore 参考：

```gitignore
Output/
Objects/
Listings/
.history/
*backups/
*.uvguix.*
JLinkLog.txt
```

Parts:
J1, J2: PH2.0-4P（卧插）; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J3: PH2.0-7P（立插）; JST_PH_B7B-PH-K_1x07_P2.00mm_Vertical

Connections:
+24V: J3.1, J3.2
/红B-: J1.1, J2.1
/绿A-: J1.3, J2.3
/黑A+: J1.4, J2.4
GND: J3.3, J3.4

Notes on the sheet:
PWM
nSleep
PY32
一定注意网络和封装的对应关系，否则电机反接！
SDA/Utx
Vref
nEnable
MS1
24V
nReset
MS3
Step
找同时具有I2C和串口的复用IO
OUT
DIR
无需微步进、睡眠
使用PWM模拟DAC输出，需要RC滤波
黑A+
MS2
红B-
电源管理
HAL490 TO-92S封装 线性霍尔
3.3V
HR4988/A4988/DRV8825
SCL/Urx

Board: 2 copper layers, 3 parts (0 on the bottom side), 5 nets, no tracks yet.

## KiCad design modular_slot_controller/设计文件/modular_slot_controller/modular_slot_controller.kicad_pcb

File modular_slot_controller/设计文件/modular_slot_controller/README.md:

# modular_slot_controller

模块化多槽位控制器 —— 液/温控模块化主控板原理图与 PCB（KiCad 10 工程）。

一块 40 × 35 mm 的控制/转接板：4 个金手指母座（SLOT1–SLOT4）、24 V / 2 A 加热体接口、
12 V 小型泵与小型阀接口、液位开关、NTC 测温与 ADC/基准电路，并通过 J11（2×8 排母）
与 J12（2×8 排针）级联到上一级 / 下一级模块。

## 功能模块

原理图按功能划分成下列功能框（与 `.kicad_sch` 中的 dashed frame 一一对应）：

| 功能框 | 说明 | 主要器件 |
| --- | --- | --- |
| 电源 | +24 V / +12 V / +3.3 V 供电与去耦（待完善） | — |
| 金手指 | 与下级板级联的金手指接口 | J6（2×5） |
| 单片机 | MCU 及其外围（待放置） | — |
| 金手指母座 SLOT1–SLOT4 | 4 路插槽接口，每路带 2 个上拉/串阻 | J7–J10、R1–R8 |
| 小型泵 12 V | 12 V 泵输出（2 路） | J4、J1 |
| 小型阀 12 V | 12 V 阀输出 | — |
| 加热体 24 V 2 A | 加热体大电流接口 | J2（XH2.54 2P） |
| 液位开关 | 液位检测输入 | J3（PH2.0 2P） |
| NTC | 热敏电阻测温输入 | J5（PH2.0 2P） |
| ADC、基准电路等 | ADC 前端与电压基准（待完善） | — |
| 连接到下一级 | 级联接口与板间总线 | J11、J12、R9（4.7 k/1 %） |
| 连接到上一级 | 级联接口 | H3–H6、J11、J12、R9 |

板间 I2C 总线使用 `SDA` / `SCL`，另有 `BoardNum`（槽位地址）、`Bit0` / `Bit1`（槽位编码）、
`GPIO` / `ADC` 等信号。

## 电气规格（当前设计值）

- 电源轨：`+24V`（加热体）、`+12V`（泵 / 阀）、`+3.3V`（逻辑）、`GND`
- 加热体：24 V / 2 A
- 板尺寸：40 × 35 mm，2 层板，1.6 mm
- 安装孔：M2（H1、H2）与 M3（H3–H6）

## 当前状态（Work in progress）

- 原理图：骨架与接口已画好；**「单片机」「电源」「ADC、基准电路等」三个功能框尚未放置器件**，
  金手指母座 J7–J10 与部分连接器也未绑定封装。
  `R1`–`R9` 多数仍为默认值 `R`，需按实际电路填入阻值。
- PCB：由 15 段 `Edge.Cuts` 组成 40 × 35 mm 外形；**尚未布线**（0 段走线 / 0 个过孔），
  且 H3–H6、J11、J12 位于板框之外，需要重新布局。
- ERC / DRC 尚未通过，此仓库目前是**设计中间版本**，不能直接投产。

## 设计注意事项（摘自原理图注释）

- NTC-ADC 需要实现在 38 °C 附近 < 0.1 °C 的温度检测，NTC 探头、采样电阻、放大电路与
  基准电压源需严格选型。
- 若 ADC 通过 I2C 与 MCU 通讯，不要与金手指共用同一路 I2C。
- 注意电源噪声对 ADC 采样的影响。

## 文件说明

| 文件 | 内容 |
| --- | --- |
| `modular_slot_controller.kicad_pro` | 工程文件：设计规则、网络类、ERC/DRC 设置 |
| `modular_slot_controller.kicad_sch` | 原理图（单页，A4） |
| `modular_slot_controller.kicad_pcb` | PCB（2 层） |

`*.kicad_prl`、`.history/`、`*-backups/`、`fp-info-cache` 等本机状态与自动备份已在
`.gitignore` 中排除，不进版本库。

## 打开方式

使用 **KiCad 10.0** 打开 `modular_slot_controller.kicad_pro`。

## 版本管理约定

- 提交一律包含 `.kicad_pro` / `.kicad_sch` / `.kicad_pcb` 三者，避免原理图与 PCB 不同步。
- 不要提交 `*.kicad_prl`、`.history/` 与 Gerber 输出。

## 版权

© Fengling Tech. Co. Ltd. 内部项目，保留所有权利。

Board: 2 copper layers, 200.0 x 95.0 mm, 13 parts (0 on the bottom side), 5 nets, no tracks yet.

Parts:
H1, H2: MountingHole; MountingHole_2.2mm_M2
H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3
J1, J3, J4, J5: PH2.0_2P; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J2: XH2.54_2P; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: 排母; PinSocket_2x08_P2.54mm_Horizontal
J12: 排针; PinHeader_2x08_P2.54mm_Horizontal

Connections:
+12V: J11.1, J12.1
+24V: J11.3, J11.5, J11.7, J11.9, J11.11, J12.3, J12.5, J12.7, J12.9, J12.11
/SCL: J11.13, J12.13
/SDA: J11.15, J12.15
GND: J11.2, J11.4, J11.6, J11.8, J11.10, J11.12, J11.14, J12.2, J12.4, J12.6, J12.8, J12.10, J12.12, J12.14

## KiCad design integrating_box_light_source/设计文件/kicad_integrating_box_light_source-main/kicad_integrating_box_light_source-main/integrating_box_light_source.kicad_pcb

File integrating_box_light_source/README.md:

# 积分盒四色光源板（光模块功能板）

胶片翻拍用「积分盒」的四色 LED 光源板与配套资料。四路 R/G/B/IR 独立恒流驱动，DAC 模拟调光，光电二极管做光强反馈。

硬件有 KiCad 与立创EDA 专业版两套工程，固件在 ESP8684（ESP32-C2）上运行。

## 1. 系统构成

```
主机 I2C ──> MCP4728 CH1~CH4 ──> AL8862 CTRL ──> 四串 LED
   │                                                   │
   └──<── ADS1110 <── OPA333 跨阻 <── BPW34S <── 积分球光
```

- **四路独立**：R / G / B / IR，每路 4 颗 3535 灯珠串联，只能整路一起亮
- **恒流驱动**：AL8862SP-13，滞环降压，`I_OUT = 0.1 V / R_SET`，CTRL 0.4~2.5 V 模拟调光
- **调光**：MCP4728 四路 12 位 DAC（I2C 0x60），CH1~CH4 对应 R/G/B/IR
- **光强反馈**：BPW34S → OPA333 跨阻（47 kΩ ∥ 10 pF）→ ADS1110（16 位 ΔΣ ADC，I2C 0x48）
- **电源**：24 V 输入 → 保险丝 + TVS + SS54 防反接 → AL8862 与 LED；LM317 线性产生 3.3 V 给 DAC/ADC/运放（模拟电源用线性，避开开关噪声）

## 2. 仓库结构

| 路径 | 内容 |
|---|---|
| `设计文件/JLC_Integrating_Sphere_Light_Source_2026-11-10.epro` | **立创EDA 专业版工程（当前打板依据）** |
| `设计文件/SCH_积分匀光箱板_2026-11-20.pdf` | 当前原理图 PDF |
| `设计文件/JLC_integrating_box_light_source/` | 立创EDA 工程的归档副本（含 zip） |
| `设计文件/kicad_integrating_box_light_source-main/` | KiCad 工程：层次原理图、PCB、BOM、DXF、器件手册 |
| `交接文档/AI_固件交接文档.md` | 固件接口、寄存器、控制流程、标定与验收 |
| `测试工程/` | 预留 |

KiCad 子工程内部：

| 文件 | 内容 |
|---|---|
| `integrating_box_light_source.kicad_pro/.kicad_sch` | 顶层：J1(24V)、J2(I2C)、上拉、7 个层次图 |
| `power_protection.kicad_sch` | 24 V 输入防护 + LM317 3V3 |
| `led_cc_driver*.kicad_sch`（含 _g/_b/_ir） | 四路恒流驱动 |
| `dac_with_external_vref.kicad_sch` | MCP4728 四路 DAC |
| `light_sensor.kicad_sch` | 光强检测前端 |
| `datasheets/` | AL8862（中/英）、MCP4728 |
| `BOM_立创编号.csv` | 下单核对用 |

## 3. 硬件要点

| 项 | 值 / 说明 |
|---|---|
| I2C | 3.3 V 逻辑，7 位地址；主板 4.7 kΩ 上拉，传感器板不要重复加强上拉 |
| MCP4728 | 0x60（A2/A1/A0=000），VREF=VDD，LDAC# 接地（写完立即更新） |
| ADS1110 | 0x48（A0=0），连续 15 SPS、增益 1，LSB 62.5 µV |
| 光强板接口 | 独立小板，J3（3V3/GND/SDA/SCL）接到主板 J2/J4 |
| 排线较长时 | 总线电容超约 75 pF 就把上拉降到 3.3 kΩ 或把速率降到 100 kHz（固件实际按 100 kHz 跑） |

## 4. 关键计算

| 项目 | 值 | 依据 |
|---|---|---|
| LED 电流（100%） | **333 mA**（KiCad 设计，R_SET=0.30 Ω） | `I_OUT = 0.1 V / R_SET` |
| LED 电流（实物实测） | **333.3 mA**（R_SET 已换成 0.30 Ω） | 固件按 333.3 mA 满量程换算 |
| CTRL 映射 | 0.4~2.5 V ↔ 10%~100%；<0.3 V 关断；>2.6 V 钳位 | AL8862 手册 |
| DAC 满码 | 3102（2.5 V @ VREF = 3.3 V） | — |
| 电感 | 100 µH | 满载 570~700 kHz，手册推荐 33~100 µH |
| 3V3 | 3.28 V | `1.25 × (1 + 390/240)` |
| 跨阻 | 47 kΩ ∥ 10 pF，带宽 339 kHz | 1.33 nA/LSB，最大可测光电流 43.6 µA |

> **R_SET 现状（2026-11-23）**：原理图设计值 0.30 Ω（333.3 mA）。实板曾装 0.50 Ω（200 mA），现已换回 **0.30 Ω**；固件 `light_cfg.h` 的 `I_FULL_MA=333.3f`。换板或换电阻时必须同步改这个常数，否则 `set <mA>` / 百分比全部偏。

## 5. 灯珠与立创编号

| 通道 | 位号 | 型号 | 立创编号 |
|---|---|---|---|
| 红 | LED_R1–R4 | XL-HD3535SURC-A2 | C3646952 |
| 绿 | LED_G1–G4 | JNJ-LEHG0113W120 | C19185875 |
| 蓝 | LED_B1–B4 | XL-HD3535UBC-A2 | C3646953 |
| 红外 | LED_IR1–IR4 | XL-HD3535HIR-T4A2 | C5221244 |
| 驱动 IC | U4–U7 | AL8862SP-13 | C526360 |

灯珠编号写在符号的 `LCSC Part` 字段里，`BOM_立创编号.csv` 由 KiCad 网表导出，可直接用于下单核对。

## 6. 打开方式

- **立创EDA 专业版**：打开 `.epro`，工程面板切换图页
- **KiCad 10**：打开 `integrating_box_light_source.kicad_pro`
  - `sym-lib-table` → `LCSC.kicad_sym`（AL8862 符号）
  - `fp-lib-table` → `integrating_box_light_source.pretty`（自建 3535 封装）
- **只看图**：直接开 `SCH_积分匀光箱板_2026-11-20.pdf`

## 7. 固件

固件工程在 ESP 侧：`F:\Boards_tests\ESP8684_design\ESP8684_RGB_BOX_Project`（独立仓库/工程，不在本目录内），自带 `_固件交接说明.md` 说明编译、烧录与控制台命令。

要点摘录：

| 项 | 值 |
|---|---|
| 芯片 | ESP8684（ESP32-C2），ESP-IDF v5.3.3 |
| I2C | GPIO0 = SDA，GPIO1 = SCL，**100 kHz**（400 kHz 实测不稳） |
| 控制台 | **UART0 74880**（ESP32-C2 + 26 MHz XTAL 的 Kconfig 默认值，不是 115200），命令：`scan/off/set/code/meas/tgt/loop/mode/cal/calsave/status/vin/mon` |
| 上电默认 | **四路 R/G/B/IR 全部点亮，各 50 mA（15%）**，code=642，CTRL≈0.52 V |
| 通道映射 | CH1=R/U4/JP1/R1；CH2=G/U5/JP2/R2；CH3=B/U6/JP3/R3；CH4=IR/U7/JP4/R4 |
| 焊桥跳线 | **JP1~JP4 必须短接**，否则 DAC 输出到 AL8862 CTRL 断开 |
| MCP4728 | 上电先发 General Call Wake-Up（`0x00, 0x09`）清 power-down 位 |
| ADS1110 | 上电重试 5 次；`meas` 失败时还会自动恢复一次（灭灯重采暗底） |

固件侧的实测结论：

- **I2C 必须 100 kHz**：400 kHz 下 ADS1110 读操作成片 NACK，MCP4728 也会偶发丢数据（表现为写成功但某通道不变）。
- **串口必须 74880**：`CONFIG_ESP_CONSOLE_UART_BAUDRATE` 在 esp32c2 + 26 MHz XTAL 下由 Kconfig 固定，手改 sdkconfig 会被覆盖。
- **低亮度档**：10%（旧 0.50 Ω 时 20 mA）AL8862 起不来；当前 0.30 Ω 下默认 15% = 50 mA，实测可亮。
- **红外不可见**：850 nm，判断是否点亮用 `meas ir` 或手机摄像头。
- **诊断命令**：`vin` 读 ADS1110 VIN+ 原始码/配置字/电压；`mon on` 每 100 ms 连续打印 `[VIN]`。
- **截至 2026-11-23 的遗留问题**：ADS1110 在 I2C 上正常（0x48 ACK、能转换、配置字会变），但 VIN+ 读数恒定在约 -3 mV，不随光照变化；怀疑 U1 pin1 虚焊或芯片输入损坏，待硬件复查。

### 7.1 2026-11-23 固件调整记录

- I2C 从 400 kHz 降到 **100 kHz**。
- 串口确认为 **74880**（文档旧值 115200 已作废）。
- MCP4728 初始化加 General Call Wake-Up。
- ADS1110 上电重试与运行中自动恢复。
- 新增 `vin` / `mon on|off` 诊断命令。
- 修正 `main/CMakeLists.txt` 组件名：`esp_console` → **`console`**。
- 修正 VS Code `idf.buildPath` 为 `${workspaceFolder}/build`（原来指向了 Empty_Project）。
- R_SET 统一为 **0.30 Ω**，`I_FULL_MA=333.3f`；上电四路各 **15%（50 mA）**，code=642。
- 通道/跳线确认：CH1=R/U4/JP1，CH2=G/U5/JP2，CH3=B/U6/JP3，CH4=IR/U7/JP4；JP1~JP4 必须短接。

## 8. 状态

**已完成**

- 原理图整机 ERC 0 error / 0 warning（KiCad 版）
- 立创EDA 版已打板，实板可点灯、可调光
- 固件：四路 DAC、光强采样、闭环与标定、控制台均已实现，编译烧录通过
- 四路 LED 均可由 DAC 驱动点亮（R/G/B 可见，IR 为 850 nm 不可见）
- 上电默认四路 15%（50 mA），I2C 100 kHz，控制台 74880

**未完成 / 待确认**

- **ADS1110 VIN+ 读数恒定（约 -3 mV），不随光照变化**；待查 U1 pin1 虚焊或芯片输入损坏
- 光强闭环与标定精度需在传感器修好后复测；闭环未做长时间温漂记录
- R_SET 已统一为 0.30 Ω（333.3 mA）；早期 0.50 Ω 的资料已过时
- 其余阻容/连接器的立创编号待补齐
- PCB 布局在 KiCad 版中标注为"进行中"，最终以立创版为准

## 9. 提交到 Git 的建议

建议**不要**把下面这些提交进仓库，体积大且无信息增益：

| 排除项 | 原因 |
|---|---|
| `kicad_.../integrating_box_light_source-backups/` | 历史备份 zip，每个 140~210 KB |
| `kicad_.../.history/` | KiCad 本地历史 |
| `*.zip`（三个 5~6 MB 的外层压缩包） | 与解压后的工程重复 |
| `Imported integrating_box_light_source/` | Altium 导入的中间产物，非当前依据 |

建议保留：`.epro`、`.kicad_pro/.kicad_sch/.kicad_pcb`、`datasheets/`、`BOM_立创编号.csv`、DXF、`SCH_*.pdf`、两份交接文档。

.gitignore 参考：

```gitignore
*backups*/
.history/
*.zip
Imported */
```

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2
J1: Conn_01x02_焊线焊盘; PinHeader_1x02_P2.54mm_Vertical
J2: Conn_01x03_焊线焊盘; PinHeader_1x03_P2.54mm_Vertical
J3, J4: FPC_0.5mm_4P_卧贴; HC-FPC-05-09-4RLTAG; LCSC C5213746
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R9, R10: 4k7; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Loop_D2.50mm_Drill1.85mm

Connections:
+3V3: J3.4, J4.1, R9.1, R10.1, TP5.1 (1_1); also elsewhere on the board
/CH1: JP1.1 (A), TP1.1 (1_1); also elsewhere on the board
/CH2: JP2.1 (A), TP2.1 (1_1); also elsewhere on the board
/CH3: JP3.1 (A), TP3.1 (1_1); also elsewhere on the board
/CH4: JP4.1 (A), TP4.1 (1_1); also elsewhere on the board
/DAC_with_external_Vref/CH1: JP1.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH2: JP2.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH3: JP3.2 (B); also elsewhere on the board
/DAC_with_external_Vref/CH4: JP4.2 (B); also elsewhere on the board
/Light_Sensor/SCL: J3.2; also elsewhere on the board
/Light_Sensor/SDA: J3.3; also elsewhere on the board
/SCL: J2.2, J4.3, R10.2; also elsewhere on the board
/SDA: J2.1, J4.2, R9.2; also elsewhere on the board
GND: J1.2, J2.3, J3.1, J4.4, TP6.1 (1_1); also elsewhere on the board
VCOM: J1.1; also elsewhere on the board

Notes on the sheet:
模拟电路，需严格恪守数据手册中的LAYOUT规范
对外接口，连接到外部单片机
MASTER BOARD
对外接口，连接到外部24V供电
R/G/B/IR四通道LED光源，配合外部结构，构成胶片翻拍积分盒 设计要点： 1. R/G/B/IR灯珠的发光频率需与胶片色罩频率匹配 2. 各通道需保持小的亮度差异，避免出现整体色偏 3. 温度将会影响电流源基准和LED灯珠工作电流及频率 4. 可以加光强传感器做闭环控制
SLAVE BOARD
I2C上拉电阻
通过FPC线连接到J3
通过FPC线连接到J4
生产时必须使用铝基板以加强散热

Parts:
C3: 10u/50V; C_1206_3216Metric
D16: SS34; D_SMB
L3: 100uH; L_1210_3225Metric
LED_B1, LED_B2, LED_B3, LED_B4: XL-HD3535UBC-A2; LED_3535_3500x3500mm; LCSC Part C3646953
R3: R30; R_1206_3216Metric
U6: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C3.1, D16.1 (K), R3.1, U6.4 (VIN); also elsewhere on the board
/CH3: U6.8 (CTRL); also elsewhere on the board
GND: C3.2, U6.2 (GND), U6.7 (GND), U6.9 (EP); also elsewhere on the board
unnamed: D16.2 (A), L3.1, U6.5 (SW), U6.6 (SW)
unnamed: LED_B1.2 (A), LED_B3.1 (K)
unnamed: L3.2, LED_B1.1 (K)
unnamed: LED_B2.2 (A), R3.2, U6.1 (SET)
unnamed: LED_B2.1 (K), LED_B4.2 (A)
unnamed: LED_B3.2 (A), LED_B4.1 (K)

Notes on the sheet:
【参数计算 — 蓝通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×3.4 V = 13.6 V（蓝光 Vf 最高，留给恒流源余量最小） t_OFF = 100µ×86.6m/(13.6+0.5+0.13) = 610 ns t_ON = 8.66µ/(24−13.6−0.13) = 845 ns → f_SW = 687 kHz（满载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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C12: 100n; C_0603_1608Metric
C13: 1u; C_0603_1608Metric
U3: MCP4728; MSOP-10_3x3mm_P0.5mm

Connections:
+3V3: C12.1, C13.1, U3.1 (VDD); also elsewhere on the board
/DAC_with_external_Vref/CH1: U3.6 (VOUTA); also elsewhere on the board
/DAC_with_external_Vref/CH2: U3.7 (VOUTB); also elsewhere on the board
/DAC_with_external_Vref/CH3: U3.8 (VOUTC); also elsewhere on the board
/DAC_with_external_Vref/CH4: U3.9 (VOUTD); also elsewhere on the board
/SCL: U3.2 (SCL); also elsewhere on the board
/SDA: U3.3 (SDA); also elsewhere on the board
GND: C12.2, C13.2, U3.4 (~LDAC), U3.10 (VSS); also elsewhere on the board

Notes on the sheet:
【说明】MCP4728 无外部基准引脚，基准取自 VDD(+3V3)：4 通道共用同一基准 → 通道间比例误差最小； 满量程 0~3.3 V，覆盖 AL8862 CTRL 的 0.4~2.5 V 全调光段。（若必须外部基准，可改 DAC7574） 【LAYOUT】VDD 的 100nF 紧靠引脚 1 并直接回地；I2C 短且远离 SW 节点；四路 VOUT 等长同层，避免与 SW 平行
【参数计算 — 调光链路与 I2C】 调光性质：MCP4728 输出直流电平 → AL8862 CTRL，属 DC（模拟）调光，非 PWM LSB = VDD/4096 = 3.3/4096 = 0.806 mV CTRL 0.4 V→10%、2.5 V→100% ⇒ 代码 497→3102（2605 级覆盖 10~100%，约 0.035%/级） （对照：PWM 调光需 CTRL 在 <0.3 V 与 >2.6 V 间切换，本设计不用） I2C 上拉：Rp,max = tr/(0.847·Cb)；400 kHz 时 tr ≤ 300 ns，板内 Cb≈50 pF ⇒ Rp ≤ 7 kΩ 现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

Parts:
C7: 10u/50V; C_1206_3216Metric
C8, C11: 100n; C_0603_1608Metric
C9: 1u/50V; C_0805_2012Metric
C10: 10u/16V; C_0805_2012Metric
D22: SMBJ30CA; D_SMB
D24: SS54; D_SMB
F1: 2A/125V; Fuse_1206_3216Metric
R6: 240; R_0603_1608Metric
R7: 390; R_0603_1608Metric
R8: 470; R_0603_1608Metric
U10: LM317; TO-252-2

Connections:
+3V3: C10.1, C11.1, R6.1, R8.1, U10.2 (VO); also elsewhere on the board
+24V: C7.1, C8.1, C9.1, D24.1 (K), U10.3 (VI); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, D22.1 (A1), R7.2, R8.2; also elsewhere on the board
unnamed: D22.2 (A2), D24.2 (A), F1.2
unnamed: R6.2, R7.1, U10.1 (ADJ)
VCOM: F1.1; also elsewhere on the board

Notes on the sheet:
【24V 输入与防护】 J1(24V) → F1 2A 保险丝 → D22 SMBJ30CA 抑制浪涌 → D24 SS54 肖特基防反接 → +24V 母线 反接时 D24 截止，后级不受损；C7/C8 为母线储能与高频旁路 保险丝：4×333 mA = 1.33 A ⇒ 2A；TVS：SMBJ30CA 关断 30 V > 24×1.1 = 26.4 V，峰值钳位 48.4 V
【LM317 计算】 VOUT = 1.25V × (1 + R7/R6) = 1.25 × (1 + 390/240) = 3.28 V 压差 24−3.3 = 20.7 V，负载 ≈ 9.1 mA → P = 20.7 × 9.1m = 0.19 W（TO-252 免散热片） R8 = 470Ω 预负载（7 mA），保证 LM317 轻载稳压；C9 输处、C10/C11 输出

Parts:
C14: 10p; C_0603_1608Metric
C15, C16: 100n; C_0603_1608Metric
D1: BPW34S-SMD; Osram_BPW34S-SMD; LCSC Part C145262
R11: 47k; R_0603_1608Metric
U1: ADS1110; SOT-23-6
U2: OPA333xxDBV; SOT-23-5

Connections:
+3V3: C15.1, C16.1, U1.5 (VDD), U2.5 (V+); also elsewhere on the board
/Light_Sensor/SCL: U1.3 (SCL); also elsewhere on the board
/Light_Sensor/SDA: U1.4 (SDA); also elsewhere on the board
GND: C15.2, C16.2, D1.1 (K), U1.2 (GND), U1.6 (VIN-), U2.2 (V-), U2.3 (+); also elsewhere on the board
unnamed: C14.2, D1.2 (A), R11.2, U2.4 (-)
unnamed: C14.1, R11.1, U1.1 (VIN+), U2.1

Notes on the sheet:
【LAYOUT】跨阻输入节点面积最小；Rf 紧靠反相输入，输入走线加保护环并保持助焊剂清洗干净 OPA333：避免热电偶效应（Avoid temperature gradients that create thermoelectric (Seebeck) effects） ——远离热源、避免异种金属结点、防止气流直吹 ADS1110：差分输入成对走线、远离 SW 节点与电感；VDD 的 100nF 就近回地
【参数计算 — 跨阻前端与 ADC】 V_OUT = I_ph × Rf = I_ph × 47k（BPW34 灵敏度典型 0.6 A/W） 例：10 µA → 0.47 V；50 µA → 2.35 V（ADS1110 满量程 ±2.048 V @PGA=1） 带宽 f_p = 1/(2π·Rf·Cf) = 1/(2π×47k×10p) = 339 kHz（Cf 兼作相位补偿） 噪声：√(4kTRf) = 28 nV/√Hz，折合总噪声 ≈ 20 µV rms（约 0.3 LSB） ADC 分辨率：LSB = 4.096/65536 = 62.5 µV ⇒ 电流分辨率 62.5µ/47k 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

Parts:
C2: 10u/50V; C_1206_3216Metric
D11: SS34; D_SMB
L2: 100uH; L_1210_3225Metric
LED_G1, LED_G2, LED_G3, LED_G4: JNJ-LEHG0113W120; LED_3535_3500x3500mm; LCSC Part C19185875
R2: R30; R_1206_3216Metric
U5: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C2.1, D11.1 (K), R2.1, U5.4 (VIN); also elsewhere on the board
/CH2: U5.8 (CTRL); also elsewhere on the board
GND: C2.2, U5.2 (GND), U5.7 (GND), U5.9 (EP); also elsewhere on the board
unnamed: D11.2 (A), L2.1, U5.5 (SW), U5.6 (SW)
unnamed: LED_G1.2 (A), LED_G3.1 (K)
unnamed: L2.2, LED_G1.1 (K)
unnamed: LED_G2.2 (A), R2.2, U5.1 (SET)
unnamed: LED_G2.1 (K), LED_G4.2 (A)
unnamed: LED_G3.2 (A), LED_G4.1 (K)

Notes on the sheet:
【参数计算 — 绿通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×3.2 V = 12.8 V（Vf 2.8~3.5 V，取典型 3.2） t_OFF = 100µ×86.6m/(12.8+0.5+0.13) = 650 ns t_ON = 8.66µ/(24−12.8−0.13) = 783 ns → f_SW = 698 kHz（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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C4: 10u/50V; C_1206_3216Metric
D21: SS34; D_SMB
L4: 100uH; L_1210_3225Metric
LED_IR1, LED_IR2, LED_IR3, LED_IR4: XL-HD3535HIR-T4A2; LED_3535_3500x3500mm; LCSC Part C5221244
R4: R30; R_1206_3216Metric
U7: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C4.1, D21.1 (K), R4.1, U7.4 (VIN); also elsewhere on the board
/CH4: U7.8 (CTRL); also elsewhere on the board
GND: C4.2, U7.2 (GND), U7.7 (GND), U7.9 (EP); also elsewhere on the board
unnamed: D21.2 (A), L4.1, U7.5 (SW), U7.6 (SW)
unnamed: LED_IR1.2 (A), LED_IR3.1 (K)
unnamed: L4.2, LED_IR1.1 (K)
unnamed: LED_IR2.2 (A), R4.2, U7.1 (SET)
unnamed: LED_IR2.1 (K), LED_IR4.2 (A)
unnamed: LED_IR3.2 (A), LED_IR4.1 (K)

Notes on the sheet:
【参数计算 — 红外通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/0.30 = 333 mA；ΔI = 26 mV/R_SET = 86.6 mA（VSET_HYS = ±13%，固定值） V_LED = 4×1.55 V = 6.2 V t_OFF = 100µ×86.6m/(6.2+0.5+0.13) = 1268 ns t_ON = 8.66µ/(24−6.2−0.13) = 487 ns → f_SW = 570 kHz（满载 CCM） 红外灯珠 Vf 温漂较大（约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
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）

Parts:
C1: 10u/50V; C_1206_3216Metric
D6: SS34; D_SMB
L1: 100uH; L_1210_3225Metric
LED_R1, LED_R2, LED_R3, LED_R4: XL-HD3535SURC-A2; LED_3535_3500x3500mm; LCSC Part C3646952
R1: R30; R_1206_3216Metric
U4: AL8862SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias; MPN AL8862SP-13; LCSC Part C526360

Connections:
+24V: C1.1, D6.1 (K), R1.1, U4.4 (VIN); also elsewhere on the board
/CH1: U4.8 (CTRL); also elsewhere on the board
GND: C1.2, U4.2 (GND), U4.7 (GND), U4.9 (EP); also elsewhere on the board
unnamed: D6.2 (A), L1.1, U4.5 (SW), U4.6 (SW)
unnamed: LED_R1.2 (A), LED_R3.1 (K)
unnamed: L1.2, LED_R1.1 (K)
unnamed: LED_R2.2 (A), R1.2, U4.1 (SET)
unnamed: LED_R2.1 (K), LED_R4.2 (A)
unnamed: LED_R3.2 (A), LED_R4.1 (K)

Notes on the sheet:
【原理】AL8862 滞环降压：VIN → R_SET → LED 串 → L → SW；开关关断时 D17(SW→VIN) 续流 【LAYOUT】SW→L/D 走线最短以降低 EMI；EP 大面积铺铜 + 散热过孔；R_SET 与 VIN/SET 用 Kelvin 接法 【焊接】3535 灯珠回流焊 240±5℃/6s，只建议返修时手工焊（<300℃/3s）
【参数计算 — 红通道 · DC 调光】 调光方式：CTRL 加 0.4~2.5 V 直流（analog / DC dimming），不是 PWM I_LED(100%) = 0.1/R_SET = 0.1/0.30 = 333 mA（V_SET 典型 100 mV） ΔI = 26 mV/R_SET = 86.6 mA —— 固定值（手册 VSET_HYS = ±13% × 100 mV），调暗时纹波不跟着变小 V_LED = 4×2.4 V = 9.6 V t_OFF = L·ΔI/(V_LED+V_D+I_LED·(R_SET+R_L)) = 100µ×86.6m/10.1 = 857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

Board: 2 copper layers, 102.0 x 30.0 mm, 78 parts (0 on the bottom side), 44 nets.
