# Keil uVision project Project.uvprojx, settings and files
target PY32F002A_Project (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: PY32F002Ax5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.5
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Ax5
  c include: ..\User;..\CMSIS\Include;..\CMSIS\Device\PY32F0xx\Include;..\PY32F0xx_HAL_Driver\Inc;..\BSP_Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002ax5.s
    ../User/: system_py32f0xx.c
  group Application/User
    ../User/: main.c py32f0xx_it.c py32f0xx_hal_msp.c app_boardid.c app_level.c app_ntc.c app_host.c
  group BSP
    ../BSP_Drivers/Bsp_Uart/: Bsp_Uart.c
    ../BSP_Drivers/Bsp_Clock/: Bsp_Clock.c
    ../BSP_Drivers/Bsp_Gpio/: Bsp_Gpio.c
    ../BSP_Drivers/Bsp_Output/: Bsp_Output.c
    ../BSP_Drivers/Bsp_Adc/: Bsp_Adc.c
    ../BSP_Drivers/Bsp_I2C1_Slave/: Bsp_I2C1_Slave.c
    ../BSP_Drivers/Bsp_I2C2_Soft/: Bsp_I2C2_Soft.c
  group PY32F0xx_HAL_Driver
    ../PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.1.2
